# Keil uVision project AutoPilot.uvprojx, settings and files
target AutoPilot (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: AutoPilot
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx,ARM_MATH_CM4,__CC_ARM
  c misc: --C99
  c include: ../Inc;                                       ../Drivers/STM32F4xx_HAL_Driver/Inc;                                       ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                       ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                                       ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;                                       ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;                                       ../Middlewares/Third_Party/FreeRTOS/Source/include;                                       ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                                       ../Drivers/CMSIS/Include;                                       ../Drivers/CMSIS/Device/ST/STM32F4xx/Include
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_uart.c stm32f4xx_ll_usb.c stm32f4xx_hal_flash.c stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_tim.c stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_crc.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: list.c timers.c tasks.c croutine.c queue.c event_groups.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ioreq.c usbd_ctlreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Application/User
    ../Src/: usbd_desc.c stm32f4xx_it.c main.c stm32f4xx_hal_timebase_TIM.c usb_device.c usbd_cdc_if.c freertos.c stm32f4xx_hal_msp.c usbd_conf.c
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Drivers/CMSIS/DSP_Lib/Source/MatrixFunctions/: arm_mat_mult_f32.c arm_mat_scale_f32.c arm_mat_sub_f32.c arm_mat_trans_f32.c
    ../Drivers/CMSIS/DSP_Lib/Source/StatisticsFunctions/: arm_std_f32.c
    ../Drivers/CMSIS/DSP_Lib/Source/FastMathFunctions/: arm_cos_f32.c arm_sin_f32.c
    ../Drivers/CMSIS/DSP_Lib/Source/CommonTables/: arm_common_tables.c arm_const_structs.c
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Devices
    ../Devices/: data_link.c motor_pwm.c battery.c mpu6000_spi.c hmc5883l_i2c.c ms5611_i2c.c xbee_api.c led.c rom.c callbacks.c receiver.c GPS.c
  group Modules
    ../Modules/: system.c sensors_task.c motor_mixer.c attitude_estimator.c commander.c situation_awareness.c sensors_calibration.c task_manager.c attitude_controller.c position_controller.c position_estimator.c
  group MathLib
    ../MathLib/: low_pass_filter.c calibration_lib.c
  group MessageTypes
    ../MessageTypes/: pid_methods.c type_methods.c
software components: CMSIS:CORE 4.1.0
